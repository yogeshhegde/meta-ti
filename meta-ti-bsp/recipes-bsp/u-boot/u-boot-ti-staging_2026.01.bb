require u-boot-ti.inc

PR = "r0"

BRANCH = "bootmlen"

SRCREV_uboot = "2908f2f87dd930250faed916354df360757856be"

DEFAULT_PREFERENCE = "-1"
